# Keil uVision project Blinky.uvprojx, settings and files
target STM32F429 RAM (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Flash OPT
    ./: STM32F42xxx_43xxx_OPT.s
  group Source Files
    ../Src/: Blinky.c
    ../Inc/: FreeRTOSConfig.h
  group FREERTOS
    ../Documentation/: Abstract.txt
    C:/Keil_v5/FREERTOS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Keil_v5/FREERTOS/FreeRTOS/Source/portable/MemMang/: heap_2.c
    C:/Keil_v5/FREERTOS/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    C:/Keil_v5/FREERTOS/FreeRTOS/Demo/Common/Full/: BlockQ.c death.c dynamic.c events.c flop.c integer.c PollQ.c print.c semtest.c
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/MDK/Boards/ST/STM32F429I-Discovery/Common/: Buttons_F429Discovery.c LED_F429Discovery.c
  group ::Device
    RTE/Device/STM32F429ZITx/: RTE_Device.h startup_stm32f429xx.s system_stm32f4xx.c stm32f4xx_hal_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
target STM32F429 Flash (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: as above
  output: Blinky +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,ICCARM
  c include: C:\Keil_v5\FREERTOS\FreeRTOS\Source\include;C:\Keil_v5\FREERTOS\FreeRTOS\Demo\Common\include;C:\Keil_v5\FREERTOS\FreeRTOS\Source\portable\RVDS\ARM_CM4F;C:\Keil_v5\ARM\Device\ARM\ARMCM4\Include;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429 OPT (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:Startup 2.1.0
